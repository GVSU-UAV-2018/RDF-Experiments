<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>localhost</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>39253</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>#!/usr/bin/env python
# -*- coding: utf-8 -*-
# 
# Copyright 2015 &lt;+YOU OR YOUR COMPANY+&gt;.
# 
# This is free software; you can redistribute it and/or modify
# it under the terms of the GNU General Public License as published by
# the Free Software Foundation; either version 3, or (at your option)
# any later version.
# 
# This software is distributed in the hope that it will be useful,
# but WITHOUT ANY WARRANTY; without even the implied warranty of
# MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
# GNU General Public License for more details.
# 
# You should have received a copy of the GNU General Public License
# along with this software; see the file COPYING.  If not, write to
# the Free Software Foundation, Inc., 51 Franklin Street,
# Boston, MA 02110-1301, USA.
# 

import sys
import numpy
import math
import socket
import struct

from gnuradio import gr

RDF_INTERMEDIATE_PORT = 12659

num_bins = 1024
std_threshold = 20 #What determines signal exists
pulse_bin_start = 510 #Starting bin for where we are looking for pulse
pulse_bin_width = ((num_bins / 2) - pulse_bin_start) * 2 #Determine how wide the signal range should be -&gt; 4 bins wide right now

class Pulse_Detect(gr.sync_block):
    """
    docstring for block Pulse_Detect
    """
    def __init__(self):
        global num_bins
        gr.sync_block.__init__(self,
            name="Pulse_Detect",
            in_sig=[(numpy.float32,num_bins)],
            out_sig=None)

    def work(self, input_items, output_items):
        global num_bins
        global snr_threshold
        global pulse_bin_start
        global pulse_bin_width
        
        signal_arr = numpy.array([])#(pulse_bin_start - 1):(pulse_bin_start + pulse_bin_width - 1)] #minus 1 because zero base array
        noise_arr = numpy.array([])
        
        for x in range (pulse_bin_start, pulse_bin_start + pulse_bin_width - 1):
            signal_arr = numpy.insert(signal_arr, 0, input_items[0][0,x])
        for x in range (0, pulse_bin_start - 1):
            noise_arr = numpy.insert(noise_arr, 0, input_items[0][0,x])
        for x in range (pulse_bin_start + pulse_bin_width, num_bins - 1):
            noise_arr = numpy.insert(noise_arr, 0, input_items[0][0,x])
            
            
        noise_mean = numpy.mean(noise_arr[0:num_bins - 1])
        signal_mean = numpy.mean(signal_arr[0:pulse_bin_width - 1])
        noise_std = numpy.std(noise_arr[0:num_bins - 1])
        total_std = numpy.std(input_items[0][0:num_bins - 1])
        
        signal_confidence = total_std / noise_std
            
        print("Noise Std: ", noise_std)
        print("Total Std: ", total_std)
        print("Confidence: ", signal_confidence)
        
        sock_send = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
        sock_send.sendto(struct.pack("!ffff", noise_mean, total_std, signal_mean, signal_confidence), ("localhost", RDF_INTERMEDIATE_PORT))
            
        return len(input_items[0])
</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(1024)</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>93750</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>1024</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
