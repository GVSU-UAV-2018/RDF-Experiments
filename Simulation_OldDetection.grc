<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>direction</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Direction</value></param>
<param><key>min_len</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>360</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>display_scale</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>150000000</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>148000000</value></param>
<param><key>step</key><value>100000</value></param>
<param><key>stop</key><value>152000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pulse_duty</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_duty_ticks</value></param>
<param><key>value</key><value>int(math.floor(pulse_duty * pulse_period_ticks))</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>pulse_period</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Pulse period (s)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_period_ticks</value></param>
<param><key>value</key><value>int(math.ceil(pulse_period * pulse_samp_rate))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_samp_rate</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>receiver_samp_rate</value></param>
<param><key>value</key><value>6000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tuner_freq</value></param>
<param><key>value</key><value>150000000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>148000000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>152000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>DirectionalAntenna</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import math


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, pattern_file_name=None, use_degrees=True, mirror=True):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Embedded Python Block',   # will show up in GRC
            in_sig=[np.float32, np.complex64],
            out_sig=[np.complex64]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.pattern_file_name = pattern_file_name
        self.resolution = 1
        self.pattern = None
        
        if pattern_file_name is not None:
            with open(pattern_file_name) as pattern_file:
                self.pattern = np.genfromtxt(pattern_file, dtype='float_', delimiter=',', skip_header=1)
            self.resolution = np.mean(np.diff(self.pattern[:, 0]))
            if not use_degrees:
                self.resolution *= math.pi / 180
            self.pattern = 10**(self.pattern[:,1]/20)
            if mirror:
                self.pattern = np.append(self.pattern, self.pattern[-1:1:-1])
            print('Pattern length:', self.pattern.size)

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        output_items[0][:] = self.pattern[np.mod((input_items[0]/self.resolution).astype(int), self.pattern.size)] * input_items[1]
        return len(output_items[0])
</value></param>
<param><key>comment</key><value>Directional Antenna Gain</value></param>
<param><key>mirror</key><value>True</value></param>
<param><key>pattern_file_name</key><value>"/home/chris/Documents/GVSU/Capstone/GNU Radio/rad_pattern.csv"</value></param>
<param><key>use_degrees</key><value>True</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>direction</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>30/10**(SNR/20)</value></param>
<param><key>comment</key><value>Noise
(Amplitude determined experimentally)</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>Signal freq</value></param>
<param><key>freq</key><value>freq - tuner_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>receiver_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>vlen</key><value>512</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>512</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>receiver_samp_rate / pulse_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>512</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>comment</key><value>Simulated output</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>receiver_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>comment</key><value>Signal pulse</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[1]*pulse_duty_ticks + [0]*(pulse_period_ticks-pulse_duty_ticks)</value></param>
</block>
<block>
<key>channels_quantizer</key>
<param><key>id</key><value>channels_quantizer_0</value></param>
<param><key>bits</key><value>10</value></param>
</block>
<block>
<key>channels_quantizer</key>
<param><key>id</key><value>channels_quantizer_0_0</value></param>
<param><key>bits</key><value>10</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>collar_detect</value></param>
<param><key>_source_code</key><value>#!/usr/bin/env python
# -*- coding: utf-8 -*-
# 
# Copyright 2015 &lt;+YOU OR YOUR COMPANY+&gt;.
# 
# This is free software; you can redistribute it and/or modify
# it under the terms of the GNU General Public License as published by
# the Free Software Foundation; either version 3, or (at your option)
# any later version.
# 
# This software is distributed in the hope that it will be useful,
# but WITHOUT ANY WARRANTY; without even the implied warranty of
# MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
# GNU General Public License for more details.
# 
# You should have received a copy of the GNU General Public License
# along with this software; see the file COPYING.  If not, write to
# the Free Software Foundation, Inc., 51 Franklin Street,
# Boston, MA 02110-1301, USA.
# 

import numpy
from gnuradio import gr

i = 0
var_avg = 0.0
var_avg_temp = 0.0
prev_time = 0.0
sample_freq_decim = 16000.0
collar_offset = sample_freq_decim/4
collar_bandwidth = 1000.0
max_bin = int(((collar_offset + collar_bandwidth/2)/sample_freq_decim) * 512)
min_bin = int(((collar_offset - collar_bandwidth/2)/sample_freq_decim) * 512)


class collar_detect(gr.sync_block):
    """
    docstring for block collar_detect
    """
    def __init__(self):
        gr.sync_block.__init__(self,
            name="collar_detect",
            in_sig=[(numpy.float32,512)],
            out_sig=None)


    def work(self, input_items, output_items):
        global var_avg
        global min_bin
        global max_bin
        global average_mag
        global i
        global var_avg_temp
        in0 = input_items[0]
    
        noise_mean = numpy.mean(in0[0][min_bin:max_bin])
        noise_norm = numpy.asarray(in0[0][min_bin:max_bin]) - noise_mean
        noise_var = numpy.var(noise_norm)
    
        if(i&lt;31):
            var_avg_temp = var_avg_temp + noise_var
            i = i + 1    
        else:
            var_avg = var_avg_temp / 31
            var_avg_temp = 0.0
            i = 0
    
        if(noise_var &gt; 5*var_avg):
            print numpy.max(noise_norm / noise_var)
    
        return len(input_items[0])

</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(512)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import scipy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_math</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>receiver_samp_rate</value></param>
<param><key>fc</key><value>tuner_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>512</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>10**(display_scale/10)</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>DirectionalAntenna</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>DirectionalAntenna</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>channels_quantizer_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>channels_quantizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>collar_detect</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>DirectionalAntenna</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_quantizer_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_quantizer_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
